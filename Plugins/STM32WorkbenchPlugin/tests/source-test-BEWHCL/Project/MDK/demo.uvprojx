# Keil uVision project demo.uvprojx, settings and files
target  ()
  c include: ..\..\User
  group 
    ../../User/: main.c
    ../../Libraries/CMSIS/Device/Source/Templates/arm/: startup_stm32h743xx.s
